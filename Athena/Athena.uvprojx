# Keil uVision project Athena.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Athena +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Libraries\inc;.\Libraries\src;.\Libraries;.\Hardware;.\User;.\Hardware\delay;.\Hardware\sys;.\Hardware\usart;.\Hardware\LED;.\Hardware\key;.\Hardware\TIM;.\Hardware\Motor
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ./Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./Libraries/: core_cm3.c system_stm32f10x.c
  group FWLB
    ./Libraries/src/: stm32f10x_gpio.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_rtc.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_spi.c stm32f10x_wwdg.c
  group USER
    ./User/: main.c plug_in.c
  group Hardware
    ./Hardware/delay/: delay.c
    ./Hardware/sys/: sys.c
    ./Hardware/usart/: usart.c
    ./Hardware/LED/: led.c
    ./Hardware/key/: key.c
    ./Hardware/TIM/: Tim_Config.c
    ./Hardware/Motor/: Motor_Setup.c
